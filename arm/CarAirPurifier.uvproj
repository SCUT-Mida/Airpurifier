# Keil uVision project CarAirPurifier.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_airpurifier +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common;..\Include;..\Include\sevices;..\Include\protocol;..\Include\AirPurifier;..\Include\sensor;..\Include\Buffer;..\Include\pwm
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup
    ./../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../Source/templates/: system_nrf51.c
  group Main
    ../: ble_config.h
    ./../: main.c
    ../Source/Buffer/: rx_buffer_queue.c
  group Protocol
    ../Source/protocol/: protocol.c application.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../Source/services/: ble_id.c ble_uart.c
  group AirPurifier
    ../Source/AirPurifier/: car_air_purifier.c delay.c gpio.c adc.c lcd13232.c rtc.c led.c fan.c
    ../Include/AirPurifier/: pin.h
  group Sensor
    ../Source/sensor/: sensor.c dht11.c pm25.c tvoc.c
  group Pwm
    ../Source/pwm/: nrf_pwm_noglitch.c
  group Libraries
    ../../../../../Source/ble/: ble_error_log.c ble_advdata.c ble_conn_params.c ble_debug_assert_handler.c
    ../../../../../Source/app_common/: pstorage.c crc16.c app_scheduler.c app_timer.c app_button.c app_gpiote.c
    ../../../../../Source/sd_common/: softdevice_handler.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: ble_app_template +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
